## u-boot/board/mj/Kconfig
```kconfig
if TARGET_MJ_BOARD

config SYS_BOARD
	default "mj"

config SYS_CONFIG_NAME
	default "mj_board"

endif
```
